DESCRIPTION = "An image for network and communication."
LICENSE = "MIT"
PR = "r1"

require cabsy-image.inc
